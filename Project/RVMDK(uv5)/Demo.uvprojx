# Keil uVision project Demo.uvprojx, settings and files
target Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,LV_CONF_INCLUDE_SIMPLE
  c misc: --gnu
  c include: ..\..\App;..\..\Libraries\CMSIS;..\..\Libraries\CMSIS\startup;..\..\Libraries\STM32F10x_StdPeriph_Driver\src;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Bsp;..\..\Hardware;..\..\Doc;..\..\middleware\Fatfs;..\..\middleware\LittlevGL;..\..\middleware\LittlevGL\porting;..\..\middleware\LittlevGL\src;..\..\middleware\LittlevGL\src\lv_core;..\..\middleware\LittlevGL\src\lv_draw;..\..\middleware\LittlevGL\src\lv_font;..\..\middleware\LittlevGL\src\lv_hal;..\..\middleware\LittlevGL\src\lv_misc;..\..\middleware\LittlevGL\src\lv_objx;..\..\middleware\LittlevGL\src\lv_themes;..\..\Hardware\LCD\TFT;..\..\lv_examples;..\..\lv_examples\lv_apps;..\..\lv_examples\lv_tests;..\..\lv_examples\lv_tutorial;..\..\lv_examples\lv_apps\demo;..\..\lv_examples\lv_tests\lv_test_theme
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x.h
  group FWlLIB
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Bsp
    ../../Bsp/: bsp.c bsp_time.c bsp_uart.c bsp_adc.c bsp_gpio.c bsp_flash.c bsp_iic.c bsp_spi.c bsp_rtc.c
  group W25Qxx
    ../../Hardware/W25Qxx/: w25qxx.c
  group AT24Cxx
    ../../Hardware/AT24Cxx/: at24cxx.c ee_simulate.c
  group SDCard
    ../../Hardware/SDCard/: sdcard_base.c stm32_eval_sdio_sd.c user_sdcard.c
  group Fatfs
    ../../middleware/Fatfs/: diskio.c ff.c ffunicode.c user_fatfs.c ffconf.h
  group Lcd
    ../../Hardware/LCD/TFT/: ili9341.c tft.c
    ../../Hardware/LCD/Touchpad/: xpt2046.c touchpad.c
  group lvgl/src
    ../../middleware/LittlevGL/src/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../../middleware/LittlevGL/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../../middleware/LittlevGL/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c
    ../../middleware/LittlevGL/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../middleware/LittlevGL/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../../middleware/LittlevGL/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../../middleware/LittlevGL/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lvgl/port
    ../../middleware/LittlevGL/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
    ../../middleware/LittlevGL/: lv_conf.h
  group GUI
    ../../lv_examples/lv_apps/demo/: demo.c img_bubble_pattern.c
    ../../lv_examples/lv_tests/lv_test_theme/: lv_test_theme_1.c
    ../../lv_examples/: lv_ex_conf.h
  group User
    ../../App/: main.c stm32f10x_it.c stm32f10x_conf.h
  group Doc
    ../../Doc/: ReadMe.txt
